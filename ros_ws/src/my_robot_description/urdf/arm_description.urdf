Commit message: _

File: ros_ws/src/my_robot_description/urdf/arm_description.urdf (robot description, URDF)
Before this commit: robot my_robot_description, 10 links, 9 joints
Links:
- link EE_Gripper_Link: mass 0.0 -> 0.001
